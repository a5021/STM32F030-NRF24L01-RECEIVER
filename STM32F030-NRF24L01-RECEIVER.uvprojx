# Keil uVision project STM32F030-NRF24L01-RECEIVER.uvprojx, settings and files
target APP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F031F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030-NRF24L01-RECEIVER +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
