# IAR project STM32F030-NRF24L01-RECEIVER.ewp, settings and files
configuration F031F6P6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F031F6 ST STM32F031F6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F031x6
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F030-NRF24L01-RECEIVER.hex
  ILINK.IlinkOutputFile: F031F6P6.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f031x6.s
  group Application/User
    ../src/: main.c
  group Drivers
    ../src/: system_stm32f0xx.c
  group Drivers/CMSIS
    ../inc/CMSIS/: cmsis_gcc.h core_cm0.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
