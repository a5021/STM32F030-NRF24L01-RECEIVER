<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F030-NRF24L01-RECEIVER.ewp</path>
  </project>
  <batchBuild />
</workspace>
